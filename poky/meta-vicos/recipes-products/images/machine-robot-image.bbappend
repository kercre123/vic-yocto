include ${BASEMACHINE}/${BASEMACHINE}-anki-robot-image.inc
