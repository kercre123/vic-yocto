SERIAL_CONSOLE = "ttyHSL0"
