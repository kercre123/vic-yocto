DEPENDS += "virtual/androidcompat"
RDEPENDS_${PN} += "glibc"
inherit androidmk_base

