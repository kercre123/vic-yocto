PR = "r14"

SRC_URI = "${CAF_GIT}/platform/external/yocto-kernel-tools;protocol=https;branch=caf_migration/yocto/master"
