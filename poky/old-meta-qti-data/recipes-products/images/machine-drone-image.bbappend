# Data OPEN SOURCE PACKAGES
include ${BASEMACHINE}/${BASEMACHINE}-drone-data-image.inc