include ${BASEMACHINE}/${BASEMACHINE}-robot-data-image.inc
