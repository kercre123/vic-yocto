# Data OPEN SOURCE PACKAGES
include ${BASEMACHINE}/${BASEMACHINE}-qsap-data-image.inc