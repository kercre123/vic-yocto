FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://CVE-2020-26243.patch \
            file://CVE-2020-5235.patch \
"

