#Apply the patch for successful compilation.

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-FreeType-Insert-tag-CC-into-CC.patch"

