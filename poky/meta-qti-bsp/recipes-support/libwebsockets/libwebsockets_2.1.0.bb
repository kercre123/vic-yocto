require libwebsockets.inc

SRC_URI[md5sum] = "4df3be57dee43aeebd54a3ed56568f50"
SRC_URI[sha256sum] = "bcc96aaa609daae4d3f7ab1ee480126709ef4f6a8bf9c85de40aae48e38cce66"
