FILESEXTRAPATHS_prepend := "${THISDIR}/gnutls:"
SRC_URI += "file://restricted_id.patch"
