SRC_URI = "${CLO_LE_GIT}/lz4.git;protocol=https;branch=caf_migration/lz4/dev"

SRC_URI += " \
            file://run-ptest \
           "
