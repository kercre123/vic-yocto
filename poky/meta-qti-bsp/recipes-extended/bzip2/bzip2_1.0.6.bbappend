ALTERNATIVE_${PN} := " "
