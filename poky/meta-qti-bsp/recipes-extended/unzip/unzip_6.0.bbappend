EXTRA_OEMAKE += " STRIP=true LF2='' \
                'CF_NOOPT=-I. -Ibzip2 -DUNIX -DACORN_FTYPE_NFS -DWILD_STOP_AT_DIR -DDATE_FORMAT=DF_YMD  -DNOMEMCPY -DNO_WORKING_ISPRINT ${CFLAGS}'"
