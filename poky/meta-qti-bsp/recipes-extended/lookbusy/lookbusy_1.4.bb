require lookbusy.inc

LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=4325afd396febcb659c36b49533135d4"

SRC_URI[md5sum] = "574398a64d52924651476dbd5b99f368"
SRC_URI[sha256sum] = "d20c04056c812a3909edc4b54a2ab35495d2cfec4524e7610792847df1fcca68"
