# List of packages installed onto the root file system as specified by the user.
include ${BASEMACHINE}/${BASEMACHINE}-psm-image.inc

require include/mdm-bootimg.inc

inherit core-image
