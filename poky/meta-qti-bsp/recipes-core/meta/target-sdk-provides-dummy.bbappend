# Extend to -dev and -src packages
DUMMYPROVIDES_append += "\
    busybox-dev \
    busybox-src \
    coreutils-dev \
    coreutils-src \
    bash-dev \
    bash-src \
    perl-dev \
    perl-src \
    pkgconfig-dev \
    pkgconfig-src \
"
