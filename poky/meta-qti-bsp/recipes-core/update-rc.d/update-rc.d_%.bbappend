SRC_URI = "${CLO_LE_GIT}/platform/external/update-rc.d;protocol=https;branch=caf_migration/github/master \
          "

PR = "r6"
