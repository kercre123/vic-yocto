# Adjust branch & URI to fetch from Codelinaro.
SRCBRANCH = "caf_migration/drains/release/${PV}/master"
GLIBC_GIT_URI = "${CLO_LE_GIT}/glibc.git;protocol=https"


