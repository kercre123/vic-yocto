RDEPENDS_${PN} += "\
                nativesdk-avbtool-sdk \
                "
