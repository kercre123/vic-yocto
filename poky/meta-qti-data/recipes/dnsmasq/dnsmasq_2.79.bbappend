#Copyright (c) 2018, Linux Foundation. All rights reserved.
#Linux Foundation chooses to take subject only to the GPLv2
#license terms, and distributes only under these terms.

LICENSE_dnsmasq = "GPLv2only"
LIC_FILES_CHKSUM = "file://COPYING;beginline=1;endline=340;md5=0636e73ff0215e8d672dc4c32c317bb3"
