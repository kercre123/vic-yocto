# Data OPEN SOURCE PACKAGES
include ${BASEMACHINE}/${BASEMACHINE}-data-image.inc