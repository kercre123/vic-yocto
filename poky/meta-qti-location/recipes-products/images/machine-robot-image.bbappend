# location open source packages
include ${BASEMACHINE}/${BASEMACHINE}-robot-location-image.inc
