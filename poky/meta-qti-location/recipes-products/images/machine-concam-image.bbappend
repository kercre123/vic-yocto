# List of Location packages installed onto the root file system.
include ${BASEMACHINE}/${BASEMACHINE}-concam-location-image.inc
