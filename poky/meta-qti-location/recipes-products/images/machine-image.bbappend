# location open source packages
include ${BASEMACHINE}/${BASEMACHINE}-location-image.inc
