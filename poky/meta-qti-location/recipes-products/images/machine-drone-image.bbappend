# List of location packages installed onto the root file system.
include ${BASEMACHINE}/${BASEMACHINE}-drone-location-image.inc
