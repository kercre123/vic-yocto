# Core OPEN SOURCE PACKAGES
require common/common-core-image.inc
include ${BASEMACHINE}/${BASEMACHINE}-core-image.inc