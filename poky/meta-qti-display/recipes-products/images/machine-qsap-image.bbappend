# display OPEN SOURCE PACKAGES
include ${BASEMACHINE}/${BASEMACHINE}-display-image.inc
