# display OPEN SOURCE PACKAGES
include ${BASEMACHINE}/${BASEMACHINE}-display-minimal-image.inc
