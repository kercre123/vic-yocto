# ss-mgr OPEN SOURCE PACKAGES
include ${BASEMACHINE}/${BASEMACHINE}-ss-mgr-image.inc
