# List of Audio packages installed onto the root file system.
include ${BASEMACHINE}/${BASEMACHINE}-minimal-image.inc
