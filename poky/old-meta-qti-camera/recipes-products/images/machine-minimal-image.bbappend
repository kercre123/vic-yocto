# Camera Open Source packages
include ${BASEMACHINE}/${BASEMACHINE}-camera-image.inc
