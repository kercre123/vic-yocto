# Camera Open Source packages
include ${BASEMACHINE}/${BASEMACHINE}-camera-robot-image.inc
