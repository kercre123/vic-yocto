# Camera Open Source packages
include ${BASEMACHINE}/${BASEMACHINE}-camera-drone-image.inc
