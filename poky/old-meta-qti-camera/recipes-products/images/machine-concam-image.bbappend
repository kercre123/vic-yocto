# Camera Open Source packages
include ${BASEMACHINE}/${BASEMACHINE}-camera-concam-image.inc
