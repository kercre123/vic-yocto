PACKAGECONFIG += "nghttp2 ssl"
