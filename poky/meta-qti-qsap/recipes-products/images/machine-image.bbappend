# List of QSAP packages installed onto the root file system.
include ${BASEMACHINE}/${BASEMACHINE}-base-image.inc
