# Core OPEN SOURCE PACKAGES
include ${BASEMACHINE}/${BASEMACHINE}-core-image.inc