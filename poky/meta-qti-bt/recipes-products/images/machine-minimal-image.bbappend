# BT OPEN SOURCE PACKAGES
include ${BASEMACHINE}/${BASEMACHINE}-bt-image.inc
