# BT OPEN SOURCE PACKAGES
include ${BASEMACHINE}/${BASEMACHINE}-robot-bt-image.inc
