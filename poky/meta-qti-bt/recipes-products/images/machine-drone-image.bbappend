# BT OPEN SOURCE PACKAGES
include ${BASEMACHINE}/${BASEMACHINE}-drone-bt-image.inc