PR .= ".2"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

inherit enable-selinux
