PR .= ".4"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

inherit with-selinux
