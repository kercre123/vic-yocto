SUMMARY = "Standard variants of the SELinux policy"
DESCRIPTION = "\
This is the reference policy for SELinux built with type enforcement \
only."

POLICY_TYPE = "standard"

include refpolicy_${PV}.inc
