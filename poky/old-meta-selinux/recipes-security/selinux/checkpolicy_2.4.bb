include selinux_20150202.inc
include ${BPN}.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=393a5ca445f6965873eca0259a17f833"

SRC_URI[md5sum] = "4d35189dcfdcf9e3b8b8466f3f706756"
SRC_URI[sha256sum] = "9bbdac28a88de4c405c769730863f3adcd266adbfa45881a5de67e3a4895bcd4"
