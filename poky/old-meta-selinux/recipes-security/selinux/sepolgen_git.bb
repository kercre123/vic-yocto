PR = "r99"
PV = "1.2.1+git${SRCPV}"

include selinux_git.inc
include ${BPN}.inc
 
LIC_FILES_CHKSUM = "file://COPYING;md5=393a5ca445f6965873eca0259a17f833"
