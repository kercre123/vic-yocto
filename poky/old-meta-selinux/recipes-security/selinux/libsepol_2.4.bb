include selinux_20150202.inc
include ${BPN}.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=a6f89e2100d9b6cdffcea4f398e37343"

SRC_URI[md5sum] = "8a75d27acf17af1911797e6b12986b50"
SRC_URI[sha256sum] = "299015d59932404c6b69d365fdecffe5c0e2f9c44e08b47286a4bfc02ee49659"
