# qmmf OPEN SOURCE PACKAGES
include ${BASEMACHINE}/${BASEMACHINE}-qmmf-image.inc
