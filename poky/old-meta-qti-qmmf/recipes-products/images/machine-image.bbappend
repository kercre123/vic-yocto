# List of Audio packages installed onto the root file system.
include ${BASEMACHINE}/${BASEMACHINE}-qmmf-image.inc
