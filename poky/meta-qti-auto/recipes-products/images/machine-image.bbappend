# Auto OPEN SOURCE PACKAGES
include ${BASEMACHINE}/${BASEMACHINE}-auto-image.inc