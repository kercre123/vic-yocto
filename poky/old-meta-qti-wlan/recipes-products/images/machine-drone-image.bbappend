# wlan open source Packages
include ${BASEMACHINE}/${BASEMACHINE}-wlan-image.inc

