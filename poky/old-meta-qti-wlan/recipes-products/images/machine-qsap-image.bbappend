# wlan open source Packages
include ${BASEMACHINE}/${BASEMACHINE}-qsap-wlan-image.inc