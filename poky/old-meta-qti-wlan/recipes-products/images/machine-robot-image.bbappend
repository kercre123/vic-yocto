# wlan open source Packages
include ${BASEMACHINE}/${BASEMACHINE}-robot-wlan-image.inc
