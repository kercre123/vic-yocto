include ${BASEMACHINE}/${BASEMACHINE}-robot-wlan-image.inc
